# Keil uVision project keil.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: keil +hex
  c flags: Optim=3
  c define: STM32F10X_MD M_PI=3.14159265358979f USE_UART_CRTP ENABLE_UART
  c misc: --preinclude stm32f10x_conf.h --preinclude errno-base.h --diag_suppress=1295,1207
  c include: .\config;.\drivers\interface;.\hal\interface;.\lib\CMSIS\Core\CM3;.\lib\FreeRTOS\include;.\lib\STM32F10x_StdPeriph_Driver\inc;.\modules\interface;.\utils\interface;.\lib\FreeRTOS\portable\ARM\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\scat.txt
  link misc: --datacompressor off
  group init
    ./init/: main.c
  group CMSIS
    ./lib/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./lib/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group FreeRTOS
    ./lib/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ./lib/FreeRTOS/portable/MemMang/: heap_4.c
    ./lib/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ./lib/FreeRTOS/portable/ARM/ARM_CM3/: port.c portmacro.h
  group config
    ./config/: config.h FreeRTOSConfig.h nvicconf.h stm32f10x_conf.h
    ./: errno-base.h
  group driver
    ./drivers/src/: adc.c exti.c hmc5883l.c i2cdev.c i2croutines.c led.c motors.c mpu6050.c ms5611.c nrf24l01.c nvic.c
    ./drivers/interface/: adc.h exti.h hmc5883l.h i2cdev.h i2croutines.h led.h motors.h mpu6050.h ms5611.h nrf24l01.h nRF24L01reg.h nvic.h
  group hal
    ./hal/interface/: eskylink.h freeRTOSdebug.h imu.h imu_types.h ledseq.h pm.h radiolink.h uart.h
    ./hal/src/: eskylink.c freeRTOSdebug.c imu.c ledseq.c pm.c radiolink.c uart.c
  group stm32peri
    ./lib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group modules
    ./modules/interface/: comm.h commander.h console.h controller.h crtp.h crtpservice.h info.h log.h param.h pid.h pidctrl.h sensfusion6.h stabilizer.h system.h worker.h
    ./modules/src/: comm.c commander.c console.c controller.c crtp.c crtpservice.c log.c param.c pid.c pidctrl.c sensfusion6.c stabilizer.c system.c worker.c
  group utils
    ./utils/interface/: cfassert.h configblock.h cpuid.h crc.h debug.h eprintf.h filter.h fp16.h version.h
    ./utils/src/: cfassert.c configblock.c cpuid.c crc.c debug.c eprintf.c filter.c fp16.c
